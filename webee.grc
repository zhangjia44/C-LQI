<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>bitTobyte_bitTobyte</key>
<param><key>id</key><value>bitTobyte_bitTobyte_1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0</value></param>
<param><key>file</key><value>/home/zj//zigbee9_webee</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>27</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zj/webee_ex/before_deconv</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>288</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zj/webee_ex/before_deinter</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>288</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zj/webee_ex/before_byte</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zj/webee_ex/after_FFT</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zj/webee_ex/before_descramble</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>216</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zj/webee_ex/before_bit</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>216</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/zj/zigbee9_double</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>80</value></param>
</block>
<block>
<key>byteTo6bit_byteTo6bit</key>
<param><key>id</key><value>byteTo6bit_byteTo6bit_0</value></param>
</block>
<block>
<key>carrier48_carrier48</key>
<param><key>id</key><value>carrier48_carrier48_0</value></param>
</block>
<block>
<key>carrier_corresponding_carrier_correponding</key>
<param><key>id</key><value>carrier_corresponding_carrier_correponding_0</value></param>
</block>
<block>
<key>deconvolution_deconvolution</key>
<param><key>id</key><value>deconvolution_deconvolution_0</value></param>
</block>
<block>
<key>decycleprefix_decycleprefix</key>
<param><key>id</key><value>decycleprefix_decycleprefix_0</value></param>
</block>
<block>
<key>deinterleaver_deinterleaver</key>
<param><key>id</key><value>deinterleaver_deinterleaver_0</value></param>
</block>
<block>
<key>demapping_my_demapping_64</key>
<param><key>id</key><value>demapping_my_demapping_64_0</value></param>
<param><key>carrier_number</key><value>64</value></param>
</block>
<block>
<key>descramble_descramble</key>
<param><key>id</key><value>descramble_descramble_0</value></param>
<param><key>seed</key><value>9</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_1</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
</block>
<connection><source_block_id>bitTobyte_bitTobyte_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>decycleprefix_decycleprefix_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>byteTo6bit_byteTo6bit_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>byteTo6bit_byteTo6bit_0</source_block_id><sink_block_id>deinterleaver_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carrier48_carrier48_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carrier48_carrier48_0</source_block_id><sink_block_id>byteTo6bit_byteTo6bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carrier_corresponding_carrier_correponding_0</source_block_id><sink_block_id>carrier48_carrier48_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deconvolution_deconvolution_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deconvolution_deconvolution_0</source_block_id><sink_block_id>descramble_descramble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decycleprefix_decycleprefix_0</source_block_id><sink_block_id>fft_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deinterleaver_deinterleaver_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deinterleaver_deinterleaver_0</source_block_id><sink_block_id>deconvolution_deconvolution_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demapping_my_demapping_64_0</source_block_id><sink_block_id>carrier_corresponding_carrier_correponding_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>descramble_descramble_0</source_block_id><sink_block_id>bitTobyte_bitTobyte_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>descramble_descramble_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_1</source_block_id><sink_block_id>demapping_my_demapping_64_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
